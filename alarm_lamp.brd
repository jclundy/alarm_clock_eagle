File: alarm_lamp.brd (EAGLE design)
At the start: 120.3 x 86.3 mm, 30 parts

Commit message: rev1 order
Other:
- board size 120.3 x 86.3 mm -> 61.9 x 54.6 mm
